# Keil uVision project keil_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: keil_project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: main.c delay.c delay.h motor.c motor.h led.c led.h track.c track.h PWM.c PWM.h bt.c bt.h Serial.c Serial.h
